options:
  parameters:
    generate_options: qt_gui
    id: qpsk_receiver_txtfile_pluto
    output_language: python
    title: qpsk_receiver_txtfile_pluto
  states: {}

blocks:
- name: access_key
  id: variable
  parameters:
    value: '''11100001010110101110100010010011'''
  states: {}
- name: alpha
  id: variable
  parameters:
    comment: |-
      Can't change alpha in real time
      for Consteallation Modulator
    value: '0.50'
  states: {}
- name: buff_size
  id: variable
  parameters:
    value: int(32768)
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: '915000000'
  states: {}
- name: constellation
  id: variable_constellation
  parameters:
    const_points: '[-1-1j, -1+1j, 1+1j, 1-1j]'
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    type: calcdist
  states: {}
- name: hdr_format
  id: variable
  parameters:
    comment: header_format_default
    value: digital.header_format_default(access_key, 0)
  states: {}
- name: interval_update
  id: variable
  parameters:
    value: int(0)
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: offset_rx
  id: variable
  parameters:
    value: '-100000'
  states: {}
- name: pluto_ip
  id: variable_config
  parameters:
    config_file: default
    option: key
    section: main
    type: string
    value: ip:192.168.2.1
    writeback: None
  states: {}
- name: rcc_taps
  id: variable_rrc_filter_taps
  parameters:
    alpha: alpha
    gain: nfilts
    ntaps: 11*sps*nfilts
    samp_rate: nfilts*samp_rate
    sym_rate: samp_rate/sps
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '16'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_sig_source_x_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: offset_rx
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_multiply_xx_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_repack_bits_bb_1_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    comment: |-
      Skip one second of samples
      to allow AGC and FLL to lock
    num_items: int(samp_rate)
    type: complex
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: constellation.bits_per_symbol()
  states: {}
- name: digital_constellation_receiver_cb_0
  id: digital_constellation_receiver_cb
  parameters:
    comment: |-
      Input comes from Symbol Sync
      Includes a Costas Loop to do phase sync
    constellation: constellation
    fmax: math.pi/2
    fmin: '-math.pi/2'
    loop_bw: 2*math.pi*0.01
  states: {}
- name: digital_correlate_access_code_xx_ts_0_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: access_key
    tagname: packet_len
    threshold: '0'
    type: byte
  states: {}
- name: digital_crc32_bb_0_0
  id: digital_crc32_bb
  parameters:
    check: 'True'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: constellation.arity()
  states: {}
- name: digital_fll_band_edge_cc_0
  id: digital_fll_band_edge_cc
  parameters:
    filter_size: sps*2+1
    rolloff: alpha
    samps_per_sym: sps
    type: cc
    w: 2*math.pi/sps/100/sps
  states: {}
- name: digital_meas_evm_cc_0
  id: digital_meas_evm_cc
  parameters:
    cons: constellation
    meas_type: digital.evm_measurement_t.EVM_PERCENT
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    constellation: constellation
    damping: '1'
    loop_bw: '0.045'
    max_dev: '1'
    nfilters: nfilts
    osps: '1'
    pfb_mf_taps: rcc_taps
    resamp_type: digital.IR_PFB_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\nfrom collections import deque\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"Embedded Python Block example - a simple multiply const\"\"\"\n\n    def __init__(self, window_size=100):\n        gr.sync_block.__init__(\n            self,\n            name=\"EVM RMS\",\n            in_sig=[np.float32],\n            out_sig=[np.float32]\n        )\n        self.window_size = window_size\n        self.buffer = deque(maxlen=window_size)\n        self.sum_squares = 0.0\n\n    def work(self, input_items, output_items):\n        in0 = input_items[0]\n        out = output_items[0]\n\n        for i, val in enumerate(in0):\n            squared = val ** 2\n            if len(self.buffer) == self.window_size:\n                removed = self.buffer.popleft()\n                self.sum_squares -= removed\n            self.buffer.append(squared)\n            self.sum_squares += squared\n\n            rms = np.sqrt(self.sum_squares / len(self.buffer))\n            out[i] = rms\n\n        return len(out)\n\n"
    window_size: '100'
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, window_size=100):
              gr.sync_block.__init__(
                  self,
                  name="EVM MAX",
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              self.window_size = window_size
              self.count = 0
              self.max_val = 0

          def work(self, input_items, output_items):
              in0 = input_items[0]
              out = output_items[0]

              
              for i in range(len(in0)):
                  self.max_val = max(self.max_val, in0[i])
                  self.count += 1
                  out[i] = self.max_val
              
              if (self.count >= self.window_size):
                  self.count = 0
                  self.max_val = 0

              return len(output_items[0])
    window_size: '100'
  states: {}
- name: epy_block_0_0_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, window_size=100):
              gr.sync_block.__init__(
                  self,
                  name="EVM MIN",
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              self.window_size = window_size
              self.min_val = 100
              self.count = 0


          def work(self, input_items, output_items):
              in0 = input_items[0]
              out = output_items[0]

              
              for i in range(len(in0)):
                  self.min_val = min(self.min_val, in0[i])
                  self.count += 1
                  out[i] = self.min_val
              
              if (self.count >= self.window_size):
                  self.count = 0
                  self.min_val = 100

              return len(output_items[0])
    window_size: '100'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      from gnuradio import gr
      import numpy as np

      class file_overwrite_sink_bytes(gr.sync_block):
          """
          A GNU Radio sink block that writes incoming bytes to a file,
          overwriting the file on each call to work().
          """

          def __init__(self, filename=""):
              gr.sync_block.__init__(
                  self,
                  name="file_overwrite_sink_bytes",
                  in_sig=[np.byte],
                  out_sig=None
              )
              self.filename = filename

          def work(self, input_items, output_items):
              data = input_items[0]

              # Convert the incoming bytes to a string
              try:
                  text = bytes(data).decode('utf-8', errors='replace')
              except Exception as e:
                  text = f"[decode error: {e}]"

              # Open in text mode and overwrite each call
              with open(self.filename, 'w', encoding='utf-8') as f:
                  f.write(text)

              f.close()
              return len(data)
    filename: '"/home/analog/Desktop/ftc_2025/exercises/8_qpsk_point_to_point_txtfile_gnuradio/receiver_pluto/received.txt"'
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: samp_rate*5
    bbdc: 'True'
    buffer_size: buff_size
    filter_source: '''Auto'''
    frequency: center_freq
    gain1: '''fast_attack'''
    manual_gain1: '10'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: pluto_ip
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: (3,0,1,1)
    label1: '''Rx Before \nCostas Loop'''
    label2: '''Rx After \nCostas Loop'''
    name: Received Constellation
    nconnections: '2'
    size: int(1024)
    tr_level: '1'
    type: complex
  states: {}
- name: qtgui_eye_sink_x_0_0
  id: qtgui_eye_sink_x
  parameters:
    grid: 'True'
    gui_hint: (3,1,1,1)
    label1: Rx Re (After Costas Loop)
    label2: Rx Im (After Costas Loop)
    samp_per_symbol: '1'
    size: '100'
    srate: samp_rate
    tr_level: '0.5'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: complex
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    grid: 'True'
    gui_hint: (2,1,1,1)
    label1: Rx
    label2: '''Rx \n+ \nFreq Offset'''
    label3: '''Rx \n+ \nFreq \nOffset \n+ \nFLL'''
    name: '"Received spectrum"'
    nconnections: '3'
    tr_chan: '2'
    tr_level: '-60'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: complex
    update_time: '0.5'
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    avg: '1'
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"EVM average (%)"'
    type: float
  states: {}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: (1,1,1,1)
    label1: Re
    label2: Im
    name: '"Received Samples (After Costas Loop)"'
    size: '1024'
    srate: samp_rate
    tr_level: '0.8'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: complex
    ymax: '3'
    ymin: '-3'
  states: {}
- name: qtgui_time_sink_x_1_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    label1: Tx
    name: EVM measurement (%)
    size: '96'
    srate: samp_rate
    type: float
    ymax: '16'
  states: {}
- name: qtgui_time_sink_x_1_1_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    label1: Tx
    name: EVM max (%)
    size: '96'
    srate: samp_rate
    type: float
    ymax: '100'
  states: {}
- name: qtgui_time_sink_x_1_1_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    label1: Tx
    name: EVM RMS (%)
    size: '96'
    srate: samp_rate
    type: float
    ymax: '16'
  states: {}
- name: qtgui_time_sink_x_1_1_0_0_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    label1: Tx
    name: EVM min (%)
    size: '96'
    srate: samp_rate
    type: float
    ymax: '16'
  states: {}

connections:
- [analog_agc_xx_0, '0', digital_fll_band_edge_cc_0, '0']
- [analog_agc_xx_0, '0', qtgui_freq_sink_x_0_0_0, '1']
- [analog_sig_source_x_0_0_0, '0', blocks_multiply_xx_0_0_0, '1']
- [blocks_multiply_xx_0_0_0, '0', analog_agc_xx_0, '0']
- [blocks_repack_bits_bb_1_0, '0', digital_crc32_bb_0_0, '0']
- [blocks_skiphead_0, '0', digital_symbol_sync_xx_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', digital_correlate_access_code_xx_ts_0_0, '0']
- [digital_constellation_receiver_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_constellation_receiver_cb_0, '1', blocks_null_sink_0_0_0, '0']
- [digital_constellation_receiver_cb_0, '2', blocks_null_sink_0_0, '0']
- [digital_constellation_receiver_cb_0, '3', blocks_null_sink_0, '0']
- [digital_constellation_receiver_cb_0, '4', digital_meas_evm_cc_0, '0']
- [digital_constellation_receiver_cb_0, '4', qtgui_const_sink_x_0_0, '1']
- [digital_constellation_receiver_cb_0, '4', qtgui_eye_sink_x_0_0, '0']
- [digital_constellation_receiver_cb_0, '4', qtgui_time_sink_x_1_0, '0']
- [digital_correlate_access_code_xx_ts_0_0, '0', blocks_repack_bits_bb_1_0, '0']
- [digital_crc32_bb_0_0, '0', epy_block_1, '0']
- [digital_diff_decoder_bb_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [digital_fll_band_edge_cc_0, '0', blocks_skiphead_0, '0']
- [digital_fll_band_edge_cc_0, '0', qtgui_freq_sink_x_0_0_0, '2']
- [digital_meas_evm_cc_0, '0', epy_block_0, '0']
- [digital_meas_evm_cc_0, '0', epy_block_0_0, '0']
- [digital_meas_evm_cc_0, '0', epy_block_0_0_0, '0']
- [digital_meas_evm_cc_0, '0', qtgui_number_sink_0, '0']
- [digital_meas_evm_cc_0, '0', qtgui_time_sink_x_1_1, '0']
- [digital_symbol_sync_xx_0, '0', digital_constellation_receiver_cb_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_const_sink_x_0_0, '0']
- [epy_block_0, '0', qtgui_time_sink_x_1_1_0_0, '0']
- [epy_block_0_0, '0', qtgui_time_sink_x_1_1_0, '0']
- [epy_block_0_0_0, '0', qtgui_time_sink_x_1_1_0_0_0, '0']
- [iio_pluto_source_0, '0', blocks_multiply_xx_0_0_0, '0']
- [iio_pluto_source_0, '0', qtgui_freq_sink_x_0_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
