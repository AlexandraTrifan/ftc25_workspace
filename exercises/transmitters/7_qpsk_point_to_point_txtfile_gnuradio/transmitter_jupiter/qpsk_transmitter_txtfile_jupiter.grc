options:
  parameters:
    generate_options: qt_gui
    id: qpsk_transmitter_txtfile_jupiter
    output_language: python
    title: qpsk_transmitter_txtfile_jupiter
  states: {}

blocks:
- name: access_key
  id: variable
  parameters:
    value: '''11100001010110101110100010010011'''
  states: {}
- name: alpha
  id: variable
  parameters:
    comment: |-
      Can't change alpha in real time
      for Consteallation Modulator
    value: '0.50'
  states: {}
- name: buff_size
  id: variable
  parameters:
    value: int(32768)
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: '3200000000'
  states: {}
- name: constellation
  id: variable_constellation
  parameters:
    const_points: '[-1-1j, -1+1j, 1+1j, 1-1j]'
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    type: calcdist
  states: {}
- name: gain_control_mode_rx0
  id: variable
  parameters:
    value: '''spi'''
  states: {state: disabled}
- name: hardwaregain_rx0
  id: variable_qtgui_range
  parameters:
    gui_hint: (5,1,1,1)
    label: Rx Gain [dBfs]
    outputmsgname: value
    showports: 'False'
    start: '0'
    step: '1'
    stop: '34'
    value: '20'
  states: {state: disabled}
- name: hardwaregain_tx0
  id: variable_qtgui_range
  parameters:
    gui_hint: (5,0,1,1)
    label: Tx Attenuation [dBfs]
    outputmsgname: value
    showports: 'False'
    start: '-41'
    step: '1'
    stop: '0'
    value: '0'
  states: {}
- name: hdr_format
  id: variable
  parameters:
    comment: header_format_default
    value: digital.header_format_default(access_key, 0)
  states: {}
- name: interval_update
  id: variable
  parameters:
    value: int(0)
  states: {}
- name: jupiter_ip
  id: variable_config
  parameters:
    config_file: default
    option: key
    section: main
    type: string
    value: ip:jupiter.local
    writeback: None
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {state: disabled}
- name: offset_rx
  id: variable
  parameters:
    value: '-150000'
  states: {state: disabled}
- name: offset_tx
  id: variable
  parameters:
    value: int(160000)
  states: {}
- name: rcc_taps
  id: variable_rrc_filter_taps
  parameters:
    alpha: alpha
    gain: nfilts
    ntaps: 11*sps*nfilts
    samp_rate: nfilts*samp_rate
    sym_rate: samp_rate/sps
  states: {state: disabled}
- name: rx_lo_freq
  id: variable
  parameters:
    value: int(center_freq)
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: '1920000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '16'
  states: {}
- name: tx_lo_freq
  id: variable
  parameters:
    value: int(center_freq)
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {state: disabled}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: offset_tx
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: offset_rx
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: blocks_complex_to_imag_0_4_0
  id: blocks_complex_to_imag
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_4_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/analog/Desktop/241003_v3/qpsk_loopback_txtfile_gnuradio/received.txt
    type: byte
    unbuffered: 'True'
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: C:/Users/VBeleca/OneDrive - Analog Devices, Inc/Desktop/transmitters_ftc2024_v1/7_qpsk_point_to_point_txtfile_gnuradio/transmitter_jupiter/padded.txt
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_float_to_short_0_0_4_0
  id: blocks_float_to_short
  parameters:
    scale: '32767'
  states: {}
- name: blocks_float_to_short_0_5_0
  id: blocks_float_to_short
  parameters:
    scale: '32767'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.6'
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_null_sink_0_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_repack_bits_bb_1_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {state: disabled}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '32767'
  states: {state: disabled}
- name: blocks_short_to_float_0_1
  id: blocks_short_to_float
  parameters:
    scale: '32767'
  states: {state: disabled}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    comment: |-
      Skip one second of samples
      to allow AGC and FLL to lock
    num_items: int(samp_rate)
    type: complex
  states: {state: disabled}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '200'
    type: byte
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: constellation.bits_per_symbol()
  states: {state: disabled}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: constellation
    differential: 'True'
    excess_bw: alpha
    samples_per_symbol: sps
  states: {}
- name: digital_constellation_receiver_cb_0
  id: digital_constellation_receiver_cb
  parameters:
    comment: |-
      Input comes from Symbol Sync
      Includes a Costas Loop to do phase sync
    constellation: constellation
    fmax: math.pi
    fmin: '-math.pi'
    loop_bw: 2*math.pi*0.03
  states: {state: disabled}
- name: digital_correlate_access_code_xx_ts_0_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: access_key
    tagname: packet_len
    threshold: '0'
    type: byte
  states: {state: disabled}
- name: digital_crc32_bb_0
  id: digital_crc32_bb
  parameters:
    check: 'False'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: digital_crc32_bb_0_0
  id: digital_crc32_bb
  parameters:
    check: 'True'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {state: disabled}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: constellation.arity()
  states: {state: disabled}
- name: digital_fll_band_edge_cc_0
  id: digital_fll_band_edge_cc
  parameters:
    filter_size: sps*2+1
    rolloff: alpha
    samps_per_sym: sps
    type: cc
    w: 2*math.pi/sps/100/sps
  states: {state: disabled}
- name: digital_protocol_formatter_bb_0
  id: digital_protocol_formatter_bb
  parameters:
    format: hdr_format
    len_tag_key: '"packet_len"'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    constellation: constellation
    damping: '1'
    loop_bw: '0.045'
    max_dev: '1'
    nfilters: nfilts
    osps: '1'
    pfb_mf_taps: rcc_taps
    resamp_type: digital.IR_PFB_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {state: disabled}
- name: iio_attr_sink_0
  id: iio_attr_sink
  parameters:
    attr_type: '0'
    channel: voltage0
    device: adrv9002-phy
    output: 'False'
    uri: jupiter_ip
  states: {state: disabled}
- name: iio_attr_sink_0_0
  id: iio_attr_sink
  parameters:
    attr_type: '0'
    channel: voltage1
    device: adrv9002-phy
    output: 'False'
    uri: jupiter_ip
  states: {state: disabled}
- name: iio_attr_sink_0_0_0
  id: iio_attr_sink
  parameters:
    attr_type: '0'
    channel: voltage1
    device: adrv9002-phy
    output: 'True'
    uri: jupiter_ip
  states: {state: disabled}
- name: iio_attr_sink_0_1
  id: iio_attr_sink
  parameters:
    attr_type: '0'
    channel: voltage0
    device: adrv9002-phy
    output: 'True'
    uri: jupiter_ip
  states: {}
- name: iio_attr_sink_0_1_0
  id: iio_attr_sink
  parameters:
    attr_type: '0'
    channel: altvoltage0
    device: adrv9002-phy
    output: 'True'
    uri: jupiter_ip
  states: {state: disabled}
- name: iio_attr_sink_0_1_0_0_0
  id: iio_attr_sink
  parameters:
    attr_type: '0'
    channel: altvoltage2
    device: adrv9002-phy
    output: 'True'
    uri: jupiter_ip
  states: {}
- name: iio_attr_sink_0_1_0_1
  id: iio_attr_sink
  parameters:
    attr_type: '0'
    channel: voltage0
    device: adrv9002-phy
    output: 'False'
    uri: jupiter_ip
  states: {state: disabled}
- name: iio_attr_updater_0
  id: iio_attr_updater
  parameters:
    attr: hardwaregain
    interval: interval_update
    value: str(hardwaregain_rx0)
  states: {state: disabled}
- name: iio_attr_updater_0_0
  id: iio_attr_updater
  parameters:
    attr: hardwaregain
    interval: interval_update
    value: str(0)
  states: {state: disabled}
- name: iio_attr_updater_0_0_0
  id: iio_attr_updater
  parameters:
    attr: hardwaregain
    interval: interval_update
    value: str(-40)
  states: {state: disabled}
- name: iio_attr_updater_0_1
  id: iio_attr_updater
  parameters:
    attr: hardwaregain
    interval: interval_update
    value: str(hardwaregain_tx0)
  states: {}
- name: iio_attr_updater_0_1_0
  id: iio_attr_updater
  parameters:
    attr: frequency
    interval: interval_update
    value: str(rx_lo_freq)
  states: {state: disabled}
- name: iio_attr_updater_0_1_0_0_0
  id: iio_attr_updater
  parameters:
    attr: frequency
    interval: interval_update
    value: str(tx_lo_freq)
  states: {}
- name: iio_attr_updater_0_1_0_1
  id: iio_attr_updater
  parameters:
    attr: gain_control_mode
    interval: interval_update
    value: gain_control_mode_rx0
  states: {state: disabled}
- name: iio_device_sink_0_1
  id: iio_device_sink
  parameters:
    buffer_size: buff_size
    channels: '[''voltage0'',''voltage1'']'
    cyclic: 'False'
    device: axi-adrv9002-tx-lpc
    device_phy: adrv9002-phy
    interpolation: '1'
    params: '[]'
    uri: jupiter_ip
  states: {}
- name: iio_device_source_0
  id: iio_device_source
  parameters:
    buffer_size: buff_size
    channels: '[''voltage0_i'',''voltage0_q'']'
    decimation: '1'
    device: axi-adrv9002-rx-lpc
    device_phy: adrv9002-phy
    params: '[]'
    uri: jupiter_ip
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: (3,0,1,1)
    label1: '''Rx Before \nCostas Loop'''
    label2: '''Rx After \nCostas Loop'''
    name: Received Constellation
    nconnections: '2'
    size: int(1024)
    tr_level: '1'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: complex
  states: {state: disabled}
- name: qtgui_eye_sink_x_0_0
  id: qtgui_eye_sink_x
  parameters:
    grid: 'True'
    gui_hint: (3,1,1,1)
    label1: Rx Re (After Costas Loop)
    label2: Rx Im (After Costas Loop)
    samp_per_symbol: '1'
    size: '100'
    srate: samp_rate
    tr_level: '0.5'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: complex
    ymax: '2'
    ymin: '-2'
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    grid: 'True'
    gui_hint: (2,0,1,1)
    label1: Tx
    name: Transmitted Spectrum
    tr_level: '-40'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: complex
    update_time: '1'
  states: {}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    grid: 'True'
    gui_hint: (2,1,1,1)
    label1: Rx
    label2: '''Rx \n+ \nFreq Offset'''
    label3: '''Rx \n+ \nFreq \nOffset \n+ \nFLL'''
    name: '"Received spectrum"'
    nconnections: '3'
    tr_level: '-60'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: complex
    update_time: '0.5'
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: (1,0,1,1)
    label1: Re
    label2: Im
    name: Transmitted Samples (After Constellation Modulator)
    size: 1024*16
    srate: samp_rate
    tr_level: '0.5'
    type: complex
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: (1,1,1,1)
    label1: Re
    label2: Im
    name: '"Received Samples (After Costas Loop)"'
    size: '1024'
    srate: samp_rate
    tr_level: '0.8'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: complex
    ymax: '3'
    ymin: '-3'
  states: {state: disabled}

connections:
- [analog_agc_xx_0, '0', digital_fll_band_edge_cc_0, '0']
- [analog_agc_xx_0, '0', qtgui_freq_sink_x_0_0_0, '1']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0_0, '1']
- [analog_sig_source_x_0_0_0, '0', blocks_multiply_xx_0_0_0, '1']
- [blocks_complex_to_imag_0_4_0, '0', blocks_float_to_short_0_0_4_0, '0']
- [blocks_complex_to_real_0_4_0, '0', blocks_float_to_short_0_5_0, '0']
- [blocks_file_source_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_float_to_complex_0, '0', blocks_multiply_xx_0_0_0, '0']
- [blocks_float_to_complex_0, '0', qtgui_freq_sink_x_0_0_0, '0']
- [blocks_float_to_short_0_0_4_0, '0', iio_device_sink_0_1, '1']
- [blocks_float_to_short_0_5_0, '0', iio_device_sink_0_1, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_multiply_xx_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_xx_0_0, '0', blocks_complex_to_imag_0_4_0, '0']
- [blocks_multiply_xx_0_0, '0', blocks_complex_to_real_0_4_0, '0']
- [blocks_multiply_xx_0_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_xx_0_0_0, '0', analog_agc_xx_0, '0']
- [blocks_repack_bits_bb_1_0, '0', digital_crc32_bb_0_0, '0']
- [blocks_short_to_float_0, '0', blocks_float_to_complex_0, '0']
- [blocks_short_to_float_0_1, '0', blocks_float_to_complex_0, '1']
- [blocks_skiphead_0, '0', digital_symbol_sync_xx_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', digital_crc32_bb_0, '0']
- [blocks_tagged_stream_mux_0, '0', digital_constellation_modulator_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', digital_correlate_access_code_xx_ts_0_0, '0']
- [digital_constellation_modulator_0, '0', blocks_multiply_const_vxx_0, '0']
- [digital_constellation_receiver_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_constellation_receiver_cb_0, '1', blocks_null_sink_0_0_0, '0']
- [digital_constellation_receiver_cb_0, '2', blocks_null_sink_0_0, '0']
- [digital_constellation_receiver_cb_0, '3', blocks_null_sink_0, '0']
- [digital_constellation_receiver_cb_0, '4', qtgui_const_sink_x_0_0, '1']
- [digital_constellation_receiver_cb_0, '4', qtgui_eye_sink_x_0_0, '0']
- [digital_constellation_receiver_cb_0, '4', qtgui_time_sink_x_1_0, '0']
- [digital_correlate_access_code_xx_ts_0_0, '0', blocks_repack_bits_bb_1_0, '0']
- [digital_crc32_bb_0, '0', blocks_tagged_stream_mux_0, '1']
- [digital_crc32_bb_0, '0', digital_protocol_formatter_bb_0, '0']
- [digital_crc32_bb_0_0, '0', blocks_file_sink_0, '0']
- [digital_diff_decoder_bb_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [digital_fll_band_edge_cc_0, '0', blocks_skiphead_0, '0']
- [digital_fll_band_edge_cc_0, '0', qtgui_freq_sink_x_0_0_0, '2']
- [digital_protocol_formatter_bb_0, '0', blocks_tagged_stream_mux_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_constellation_receiver_cb_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_const_sink_x_0_0, '0']
- [iio_attr_updater_0, out, iio_attr_sink_0, attr]
- [iio_attr_updater_0_0, out, iio_attr_sink_0_0, attr]
- [iio_attr_updater_0_0_0, out, iio_attr_sink_0_0_0, attr]
- [iio_attr_updater_0_1, out, iio_attr_sink_0_1, attr]
- [iio_attr_updater_0_1_0, out, iio_attr_sink_0_1_0, attr]
- [iio_attr_updater_0_1_0_0_0, out, iio_attr_sink_0_1_0_0_0, attr]
- [iio_attr_updater_0_1_0_1, out, iio_attr_sink_0_1_0_1, attr]
- [iio_device_source_0, '0', blocks_short_to_float_0, '0']
- [iio_device_source_0, '1', blocks_short_to_float_0_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
