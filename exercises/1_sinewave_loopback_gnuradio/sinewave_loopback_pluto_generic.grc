options:
  parameters:
    generate_options: qt_gui
    id: sinewave_loopback_pluto
    output_language: python
    title: sinewave_loopback_pluto
  states: {}

blocks:
- name: buff_size
  id: variable
  parameters:
    value: int(32768)
  states: {}
- name: config_phy
  id: variable_config
  parameters:
    config_file: default
    option: key
    section: main
    type: string
    value: ad9361-phy
    writeback: None
  states: {}
- name: config_rx
  id: variable_config
  parameters:
    config_file: default
    option: key
    section: main
    type: string
    value: cf-ad9361-lpc
    writeback: None
  states: {}
- name: config_tx
  id: variable_config
  parameters:
    config_file: default
    option: key
    section: main
    type: string
    value: cf-ad9361-dds-core-lpc
    writeback: None
  states: {}
- name: interval_update
  id: variable
  parameters:
    value: int(0)
  states: {}
- name: lo_freq_rx
  id: variable
  parameters:
    value: '3200000000'
  states: {}
- name: lo_offset
  id: variable
  parameters:
    value: int(0)
  states: {}
- name: pluto_ip
  id: variable_config
  parameters:
    config_file: default
    option: key
    section: main
    type: string
    value: ip:192.168.2.1
    writeback: None
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    label: Rx Gain
    start: '0'
    step: '1'
    stop: '60'
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: sine_frequency
  id: variable_qtgui_range
  parameters:
    gui_hint: (0,0,1,2)
    label: Transmitted Sine Frequency [Hz]
    start: '-300000'
    step: '1'
    stop: '300000'
    value: '10000'
  states: {}
- name: tx_attenuation
  id: variable_qtgui_range
  parameters:
    label: Tx Attenuation
    start: '-89'
    step: '1'
    stop: '0'
    value: '-70'
  states: {}
- name: tx_lo_freq
  id: variable
  parameters:
    value: int(3200000000+ lo_offset)
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: sine_frequency
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: blocks_complex_to_imag_0_4_0
  id: blocks_complex_to_imag
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_4_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_float_to_short_0_0_4_0
  id: blocks_float_to_short
  parameters:
    scale: '32767'
  states: {}
- name: blocks_float_to_short_0_5_0
  id: blocks_float_to_short
  parameters:
    scale: '32767'
  states: {}
- name: iio_attr_sink_0_0_0
  id: iio_attr_sink
  parameters:
    attr_type: '0'
    channel: voltage1
    device: config-phy
    output: 'True'
    uri: pluto_ip
  states: {state: disabled}
- name: iio_attr_sink_0_1
  id: iio_attr_sink
  parameters:
    attr_type: '0'
    channel: voltage0
    device: config_phy
    output: 'True'
    uri: pluto_ip
  states: {}
- name: iio_attr_sink_0_1_0_0
  id: iio_attr_sink
  parameters:
    attr_type: '0'
    channel: altvoltage1
    device: config_phy
    output: 'True'
    uri: pluto_ip
  states: {}
- name: iio_attr_updater_0_0_0
  id: iio_attr_updater
  parameters:
    attr: hardwaregain
    interval: interval_update
    value: str(-40)
  states: {state: disabled}
- name: iio_attr_updater_0_1
  id: iio_attr_updater
  parameters:
    attr: hardwaregain
    interval: interval_update
    value: str(tx_attenuation)
  states: {}
- name: iio_attr_updater_0_1_0_0
  id: iio_attr_updater
  parameters:
    attr: frequency
    interval: interval_update
    value: str(tx_lo_freq)
  states: {}
- name: iio_device_sink_0_1
  id: iio_device_sink
  parameters:
    buffer_size: buff_size
    channels: '[''voltage0'',''voltage1'']'
    cyclic: 'False'
    device: config_tx
    device_phy: config_phy
    interpolation: '1'
    params: '[]'
    uri: pluto_ip
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: samp_rate*5
    bbdc: 'True'
    buffer_size: buff_size
    filter_source: '''Auto'''
    frequency: lo_freq_rx
    gain1: '''manual'''
    manual_gain1: rx_gain
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: pluto_ip
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: (3,0,1,2)
    name: '"Received constellation"'
    size: '1024'
    type: complex
    update_time: '0.50'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '32768'
    gui_hint: (2,1,1,1)
    name: '"Received spectrum"'
    norm_window: 'True'
    tr_level: '-60'
    type: complex
    wintype: window.WIN_FLATTOP
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    gui_hint: (2,0,1,1)
    name: Transmitted Spectrum
    norm_window: 'True'
    tr_level: '-15'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: complex
    ymin: '-240'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: (1,0,1,1)
    name: '"Transmitted samples"'
    size: 1024*8
    srate: samp_rate
    tr_level: '0.5'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: complex
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    gui_hint: (1,1,1,1)
    name: '"Received Samples"'
    size: 1024*8
    srate: samp_rate
    tr_level: '0.4'
    type: complex
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_complex_to_imag_0_4_0, '0']
- [analog_sig_source_x_0, '0', blocks_complex_to_real_0_4_0, '0']
- [analog_sig_source_x_0, '0', qtgui_freq_sink_x_1, '0']
- [analog_sig_source_x_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_imag_0_4_0, '0', blocks_float_to_short_0_0_4_0, '0']
- [blocks_complex_to_real_0_4_0, '0', blocks_float_to_short_0_5_0, '0']
- [blocks_float_to_short_0_0_4_0, '0', iio_device_sink_0_1, '1']
- [blocks_float_to_short_0_5_0, '0', iio_device_sink_0_1, '0']
- [iio_attr_updater_0_0_0, out, iio_attr_sink_0_0_0, attr]
- [iio_attr_updater_0_1, out, iio_attr_sink_0_1, attr]
- [iio_attr_updater_0_1_0_0, out, iio_attr_sink_0_1_0_0, attr]
- [iio_pluto_source_0, '0', qtgui_const_sink_x_0, '0']
- [iio_pluto_source_0, '0', qtgui_freq_sink_x_0, '0']
- [iio_pluto_source_0, '0', qtgui_time_sink_x_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
